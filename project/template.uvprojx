# Keil uVision project template.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: GD32F405RG GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.4.0
  cpu: IRAM(0x20000000,0x020000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: template +hex
  AfterMake: D:\Keil_v5\ARM\ARMCC\bin\fromelf.exe  --bin --output=@L.bin  !L
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: GD32F405, __FPU_PRESENT
  c include: ..\CMSIS;..\Library\Include;..\User;..\Peripheral\UART;..\Peripheral\SYS;..\Peripheral\Timer;..\Peripheral\SPI;..\Peripheral\EXTI;..\Peripheral\I2C;..\Navi;..\Navi\navi_config;..\Navi\navi_core;..\Navi\navi_math;..\Navi\navi_kalman;..\Navi\navi_kalman\kalman15d;..\Navi\navi_compensation
  library: MicroLIB
  memory RVCT4: ROM 0x8008000 size 0x78000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CMSIS
    ../CMSIS/: system_gd32f4xx.c gd32f4xx.h
  group Startup
    ../Startup/: startup_gd32f405.s
  group Library
    ../Library/Source/: gd32f4xx_adc.c gd32f4xx_can.c gd32f4xx_crc.c gd32f4xx_ctc.c gd32f4xx_dac.c gd32f4xx_dbg.c gd32f4xx_dci.c gd32f4xx_dma.c gd32f4xx_enet.c gd32f4xx_exmc.c gd32f4xx_exti.c gd32f4xx_fmc.c gd32f4xx_fwdgt.c gd32f4xx_gpio.c gd32f4xx_i2c.c gd32f4xx_ipa.c gd32f4xx_iref.c gd32f4xx_misc.c gd32f4xx_pmu.c gd32f4xx_rcu.c gd32f4xx_rtc.c gd32f4xx_sdio.c gd32f4xx_spi.c gd32f4xx_syscfg.c gd32f4xx_timer.c gd32f4xx_tli.c gd32f4xx_trng.c gd32f4xx_usart.c gd32f4xx_wwdgt.c
    ../Library/Include/: gd32f4xx_adc.h gd32f4xx_can.h gd32f4xx_crc.h gd32f4xx_ctc.h gd32f4xx_dac.h gd32f4xx_dbg.h gd32f4xx_dci.h gd32f4xx_dma.h gd32f4xx_enet.h gd32f4xx_exmc.h gd32f4xx_exti.h gd32f4xx_fmc.h gd32f4xx_fwdgt.h gd32f4xx_gpio.h gd32f4xx_i2c.h gd32f4xx_ipa.h gd32f4xx_iref.h gd32f4xx_misc.h gd32f4xx_pmu.h gd32f4xx_rcu.h gd32f4xx_rtc.h gd32f4xx_sdio.h gd32f4xx_spi.h gd32f4xx_syscfg.h gd32f4xx_timer.h gd32f4xx_tli.h gd32f4xx_trng.h gd32f4xx_usart.h gd32f4xx_wwdgt.h
  group User
    ../User/: main.c systick.c gd32f4xx_it.c ADXL357.c ADXL357.h XV7021.c XV7021.h main.h version.h version.c IMU_FRAME.c IMU_FRAME.h mmc5983ma.c mmc5983ma.h navi_pipeline.c navi_pipeline.h gnss1_rx.c gnss1_rx.h
  group Navi
    ../Navi/: navi_api.c navi_api.h constants.h
    ../Navi/navi_config/: navi_types.h navi_constants.h navi_filter_params.h GNSS_Infor.h
    ../Navi/navi_core/: navi_ins.c navi_ins.h navi_earth.c navi_earth.h navi_attitude.c navi_attitude.h navi_ahrs.c navi_ahrs.h navi_coarse_align.c navi_coarse_align.h
    ../Navi/navi_math/: navi_vector.c navi_vector.h navi_matrix.c navi_matrix.h mat_inverse.c math_matrix.h
    ../Navi/navi_kalman/: navi_kalman7d.c navi_kalman7d.h navi_kalman12d.c navi_kalman12d.h navi_kalman19d.c navi_kalman19d.h
    ../Navi/navi_kalman/kalman15d/: Kalman15d_Init.c Kalman15d_TimeUpdate.c Kalman15d_MeaUpdate.c Kalman_FeedBack.c GetKalman15d_SSMat.c kalman15d.h Kalman15d_SSMat.h
    ../Navi/navi_compensation/: navi_error_comp.c navi_error_comp.h navi_leverarm.c navi_leverarm.h navi_time_sync.c navi_time_sync.h GetFlag_GNSS_type.c
  group Peripheral
    ../Peripheral/UART/: uart.c uart.h
    ../Peripheral/SYS/: sys.c sys.h
    ../Peripheral/Timer/: timer.c timer.h
    ../Peripheral/SPI/: spi.c spi.h
    ../Peripheral/EXTI/: exti.c exti.h
    ../Peripheral/I2C/: i2c.c i2c.h
